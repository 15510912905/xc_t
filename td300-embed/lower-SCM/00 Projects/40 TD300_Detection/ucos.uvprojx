# Keil uVision project ucos.uvprojx, settings and files
target TD300_Detection (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103RE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000,0x00010000) IROM(0x08000000,0x00080000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: ucos +hex
  c flags: Optim=1 uC99=1 v6Lang=1 v6LangP=1
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER,TD300_DETECTION
  c include: ..\01 Sample_Module;..\..\01 FWlib\inc;..\..\02 uCOSii\Ports;..\..\02 uCOSii\Source;..\..\03 Driver\00 Config;..\..\03 Driver\01 Core;..\..\03 Driver\02 Bsp;..\..\03 Driver\02 Bsp\BSP_Sys;..\..\03 Driver\02 Bsp\BSP_Can;..\..\03 Driver\02 Bsp\BSP_Gpio;..\..\03 Driver\02 Bsp\BSP_Timer;..\..\03 Driver\02 Bsp\BSP_Spi;..\..\03 Driver\03 Device\Drv_Led;..\..\03 Driver\03 Device\Drv_Valve;..\..\03 Driver\03 Device\Drv_Pump;..\..\03 Driver\03 Device\Drv_PWM_TimerDriven;..\..\03 Driver\03 Device\Drv_StepMotor;..\..\03 Driver\03 Device\Drv_MotionControlComponents;..\..\03 Driver\03 Device\Drv_CANProtocol;..\..\03 Driver\03 Device\Drv_SimulateSpi;..\..\03 Driver\03 Device\Drv_MAX5402EUA;..\..\03 Driver\03 Device\Drv_MAX4634EUB;..\..\03 Driver\03 Device\Drv_AD7685;..\..\03 Driver\03 Device\Drv_SwitchingSensor;..\..\04 Function\00 Func_Common;..\..\04 Function\40 Func_TD300_Detection;..\..\05 Protocol\Prt_CmdRegedit;..\..\05 Protocol\Prt_CmdScheduler;..\..\05 Protocol\Prt_CmdDoubleList;..\..\06 Managemen;..\..\03 Driver\02 Bsp\BSP_Uart;..\..\03 Driver\03 Device\Drv_EM1399;..\..\03 Driver\03 Device\Drv_AT24C32;..\..\03 Driver\03 Device\Drv_SimulateIic
  asm include: ..\uCOS-II\Ports
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group FWlib
    ../../01 FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group uCOSii\Ports
    ../../02 uCOSii/Ports/: os_cpu_c.c os_dbg.c os_cpu_a.asm
  group uCOSii\Source
    ../../02 uCOSii/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group Driver\Core
    ../../03 Driver/01 Core/: stm32f10x_it.c system_stm32f10x.c startup_stm32f10x_hd.s
  group Driver\Bsp
    ../../03 Driver/02 Bsp/BSP_Timer/: BSP_Timer.c
    ../../03 Driver/02 Bsp/BSP_Gpio/: BSP_Gpio.c
    ../../03 Driver/02 Bsp/BSP_Can/: BSP_Can.c
    ../../03 Driver/02 Bsp/BSP_Sys/: BSP_Sys.c
    ../../03 Driver/02 Bsp/BSP_Spi/: BSP_Spi.c
  group Driver\Device
    ../../03 Driver/03 Device/Drv_Led/: Drv_Led.c
    ../../03 Driver/03 Device/Drv_Valve/: Drv_Valve.c
    ../../03 Driver/03 Device/Drv_Pump/: Drv_Pump.c
    ../../03 Driver/03 Device/Drv_PWM_TimerDriven/: Drv_PWM_TimerDriven.c
    ../../03 Driver/03 Device/Drv_StepMotor/: Drv_StepMotor.c
    ../../03 Driver/03 Device/Drv_MotionControlComponents/: Drv_MotionControlComponents.c
    ../../03 Driver/03 Device/Drv_CANProtocol/: Drv_CANProtocol.c
    ../../03 Driver/03 Device/Drv_SimulateSpi/: Drv_SimulateSpi.c
    ../../03 Driver/03 Device/Drv_MAX5402EUA/: Drv_MAX5402EUA.c
    ../../03 Driver/03 Device/Drv_MAX4634EUB/: Drv_MAX4634EUB.c
    ../../03 Driver/03 Device/Drv_AD7685/: Drv_AD7685.c
    ../../03 Driver/03 Device/Drv_SwitchingSensor/: Drv_SwitchingSensor.c
    ../../03 Driver/03 Device/Drv_SimulateIic/: Drv_SimulateIic.c
    ../../03 Driver/03 Device/Drv_AT24C32/: Drv_AT24C32.c
  group Function\Common
    ../../04 Function/00 Func_Common/: Func_Common.c
  group Function\TD300_Detection
    ../../04 Function/40 Func_TD300_Detection/: Func_TD300_Detection.c
  group Protocol
    ../../05 Protocol/Prt_CmdRegedit/: Prt_CmdRegedit.c
    ../../05 Protocol/Prt_CmdScheduler/: Prt_CmdScheduler.c
    ../../05 Protocol/Prt_CmdDoubleList/: Prt_CmdDoubleList.c
  group Management
    ../../06 Management/: Main.c Task.c Task.h
software components: CMSIS:CORE 5.0.1
