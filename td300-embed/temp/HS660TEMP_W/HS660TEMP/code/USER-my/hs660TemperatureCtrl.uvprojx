# Keil uVision project hs660TemperatureCtrl.uvprojx, settings and files
target Target 1 (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103CB STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00020000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Hs660TransportCtrl +hex
  c flags: Optim=1 v6Lang=1 v6LangP=1 wLevel=1
  c define: USE_STDPERIPH_DRIVER
  c include: .\USER-mix;.\CORE;..\uCOS-II\Source;..\uCOS-II\Ports;..\Config;.\APP;..\STM32F10x_FWlib\inc;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\USER;..\APP;..\APP\com;..\APP;..\SYSTEM\usart;..\USER-my;..\APP\mixs;..\APP\mixs;..\HARDWARE\LED;..\HARDWARE\SWITCH;..\HARDWARE\PID;..\HARDWARE\TEMP;..\HARDWARE\FLASH;..\CORE
  asm include: ..\uCOS-II\Ports
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ./: main.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group HARDWARE
    ../HARDWARE/LED/: led.c
    ../HARDWARE/SWITCH/: switch.c
    ../HARDWARE/TEMP/: TempCollecte.c TEMP_Sample.c tempControl.c
    ../HARDWARE/PID/: PID.c
    ../HARDWARE/FLASH/: stmflash.c
  group CORE
    ../CORE/: startup_stm32f10x_hd.s stm32f10x_it.c
  group FWlib
    ../CORE/: system_stm32f10x.c
    ../STM32F10x_FWlib/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_adc.c stm32f10x_flash.c
  group uCOS-II\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mem.c os_q.c os_sem.c os_task.c os_time.c
  group uCOS-II\Ports
    ../uCOS-II/Ports/: os_cpu_a.asm os_cpu_c.c os_dbg.c
  group Config
    ../uCOS-II/Ports/: os_cpu.h
    ../Config/: app_cfg.h os_cfg.h includes.h
  group APP
    ../APP/mixs/: product.c task.c act.c
  group text
    ./: readme.txt
software components: CMSIS:CORE 5.1.2
